SRC_URI += "file://kernel-config.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
