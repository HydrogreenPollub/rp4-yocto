# TODO find a better way to not send kernel logs to LORA
CMDLINE:append = " loglevel=0"